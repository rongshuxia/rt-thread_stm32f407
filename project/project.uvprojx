# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: ..\libcpu\arm\cortex-m4;..\libcpu\arm\common;..\components\drivers\include;..\components\drivers\include;..\components\drivers\include;..\board;..\board\ports;..\board\libraries\HAL_Drivers;..\board\libraries\HAL_Drivers\config;..\components\finsh;..\components\libc\compilers\common;..\components\net\lwip-1.4.1\src;..\components\net\lwip-1.4.1\src\include;..\components\net\lwip-1.4.1\src\include\ipv4;..\components\net\lwip-1.4.1\src\arch\include;..\components\net\lwip-1.4.1\src\include\netif;..\board\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\board\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\board\libraries\STM32F4xx_HAL\CMSIS\Include;..\applications;..\board;..\board\ATK_MC2640;..\os\include;..\board\ILI9341;..\board\lvgl;..\board\lvgl\lvgl;..\board\rtt
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ../applications/: main.c eth_camera.c app_ui.c
  group board
    ../board/: board.c stm32f4xx_hal_msp.c phy_reset.c stm32f4_delay.c bsp_led.c bsp_adc.c
  group RTT
    ../board/rtt/: SEGGER_RTT.c rtt_log.c
  group CMSIS
    ../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../libcpu/arm/common/: div0.c
    ../board/: startup_stm32f407xx.s
  group DeviceDrivers
    ../components/drivers/misc/: pin.c
    ../components/drivers/serial/: serial.c
    ../components/drivers/src/: completion.c dataqueue.c
  group Drivers
    ../board/libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_eth.c drv_common.c
  group finsh
    ../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group Kernel
    ../os/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group STM32_HAL
    ../board/: system_stm32f4xx.c
    ../board/libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group LwIP
    ../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../components/net/lwip-1.4.1/src/apps/ping/: ping.c
  group ATK_MC2640
    ../board/ATK_MC2640/: atk_mc2640.c atk_mc2640_dcmi.c atk_mc2640_sccb.c
  group ILI9341
    ../board/ILI9341/: ili9341.c
  group lv_port
    ../board/lvgl/: lv_port.c
  group STM32_HAL_FSMC
    ../board/libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group lvgl_core
    ../board/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../board/lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../board/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../board/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../board/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../board/lvgl/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../board/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../board/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../board/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../board/lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group lvgl_extra
    ../board/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../board/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../board/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../board/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../board/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../board/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../board/lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../board/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../board/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../board/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../board/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../board/lvgl/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../board/lvgl/lvgl/src/extra/: lv_extra.c
    ../board/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../board/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../board/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../board/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../board/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../board/lvgl/lvgl/src/extra/others/msg/: lv_msg.c
    ../board/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../board/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../board/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../board/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../board/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../board/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../board/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../board/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../board/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../board/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../board/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../board/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../board/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../board/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../board/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../board/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../board/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../board/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../board/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../board/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../board/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
  group lvgl_font
    ../board/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl_hal
    ../board/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../board/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../board/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
